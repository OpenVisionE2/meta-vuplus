require vuplus-stb-kodi.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

require vuplus-stb-kodi.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

require vuplus-stb-kodi.inc

SRC_URI_append = " file://vuplus-fix-exception-duo4k-19.patch"

COMPATIBLE_MACHINE = "^(vuduo4k)$"

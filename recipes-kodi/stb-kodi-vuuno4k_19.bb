require vuplus-stb-kodi.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

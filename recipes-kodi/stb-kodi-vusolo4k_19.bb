require vuplus-stb-kodi.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

require vuplus-blindscan-utils.inc

COMPATIBLE_MACHINE = "vusolo"
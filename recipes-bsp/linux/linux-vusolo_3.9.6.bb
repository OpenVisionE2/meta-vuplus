require linux-vuplus-3.9.6.inc

COMPATIBLE_MACHINE = "vusolo"
